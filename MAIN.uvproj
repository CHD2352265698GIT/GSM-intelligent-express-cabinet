# Keil uVision project MAIN.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: MAIN +hex
  c flags: Optimize=9 SizeSpeed=1
  link misc: REMOVEUNUSED
  group Source Group 1
    ./: STARTUP.A51 MAIN.c LCD12864.c GSM800C.c key.c config.h
